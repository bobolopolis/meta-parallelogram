# Fails to build without x11 in DISTRO_FEATURES
PACKAGECONFIG_remove = "pango"
