# Removing idn support makes curl smaller than wget
PACKAGECONFIG:remove = "libidn"
