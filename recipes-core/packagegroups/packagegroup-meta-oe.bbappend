RDEPENDS_packagegroup-meta-oe-core_remove = " \
    emlog \
    glfw \
    kernel-module-emlog \
    sdbus-c++ \
"

RDEPENDS_packagegroup-meta-oe-bsp_remove = " \
    firmwared \
    lmsensors \
    lmsensors-config-cgi \
    lmsensors-config-fancontrol \
    lmsensors-config-sensord \
"

RDEPENDS_packagegroup-meta-oe-dbs_remove = " \
    influxdb \
"

RDEPENDS_packagegroup-meta-oe-devtools_remove = " \
    ldns \
"

RDEPENDS_packagegroup-meta-oe-extended_remove = " \
    collectd \
    icewm \
    libcec \
    rrdtool \
    sanlock \
    wxwidgets \
"

RDEPENDS_packagegroup-meta-oe-kernel = ""
RDEPENDS_packagegroup-meta-oe-kernel_remove = " \
    cpupower \
    turbostat \
    intel-speed-select \
"
RDEPENDS_packagegroup-meta-oe-multimedia_remove = " \
    libvpx \
    pipewire \
"

RDEPENDS_packagegroup-meta-oe-support_remove = " \
    funyahoo-plusplus \
    icyque \
    geis \
    libcanberra \
    libnice \
    opencv \
    pidgin \
    pidgin-sipe \
    purple-skypeweb \
    pidgin-sipe \
    remmina \
    vboxguestdrivers \
"
