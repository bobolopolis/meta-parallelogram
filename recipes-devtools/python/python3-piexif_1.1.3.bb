SUMMARY = "To simplify exif manipulations with python. Writing, reading, and more..."
HOMEPAGE = "https://github.com/hMatoba/Piexif"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=de3294fd570f87ece3b7ab7ccd61a108"

SRC_URI[sha256sum] = "83cb35c606bf3a1ea1a8f0a25cb42cf17e24353fd82e87ae3884e74a302a5f1b"

inherit pypi

PYPI_PACKAGE_EXT = "zip"
