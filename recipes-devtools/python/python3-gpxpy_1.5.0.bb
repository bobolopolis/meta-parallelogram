SUMMARY = "GPX file parser and GPS track manipulation library"
HOMEPAGE = "https://github.com/tkrajina/gpxpy"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI[sha256sum] = "e6993a8945eae07a833cd304b88bbc6c3c132d63b2bf4a9b0a5d9097616b8708"

inherit pypi
