SUMMARY = "Read Exif metadata from tiff and jpeg files"
HOMEPAGE = "https://github.com/ianare/exif-py"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=29d43fbb76ac97cb4dab45a84e1bfa27"

SRC_URI[sha256sum] = "a0f74af5040168d3883bbc980efe26d06c89f026dc86ba28eb34107662d51766"

inherit pypi

PYPI_PACKAGE = "ExifRead"
